## hw/kp/Kconfig
```kconfig
config KP_MEM_FILE
    bool
    default y

config KP_EDI
    bool
    default y

config KP_ARGS_DEVICE
    bool
    default y
```
